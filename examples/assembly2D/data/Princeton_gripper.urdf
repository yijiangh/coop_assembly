Commit message: debugging grasp

File: examples/assembly2D/data/Princeton_gripper.urdf (robot description, URDF)
Before this commit: robot Princeton_gripper, 3 links, 2 joints
Joints:
- joint eef_base_to_tcp: origin xyz=0.0 0.0 0.3705 rpy=0 0 0 -> xyz=0.0 0.0 0.3705 rpy=0 0 1.5708
